# Autodesk Inventor assembly: 21.0019 T SHEET VA
## iProperties
Created: 2012-11
Part Number: 21.0019 T SHEET VA
Document SubType Name: Assembly
Designer: Administrator
Author: Administrator
